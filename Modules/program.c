#include <program.h>
#include <stdio.h>
#include <string.h>


static const unsigned char aucCRCHi[] = {
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0,
    0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1,
    0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0,
    0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1,
    0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40
};
static const unsigned char aucCRCLo[] = {
    0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7, 0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C,
    0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E, 0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09, 0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9,
    0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC, 0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17,
    0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3, 0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32,
    0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D, 0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A,
    0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF,
    0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26, 0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21,
    0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1, 0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4,
    0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F, 0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8,
    0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA, 0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
    0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0, 0x50, 0x90, 0x91, 0x51, 0x93, 0x53,
    0x52, 0x92, 0x96, 0x56, 0x57, 0x97, 0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C, 0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E,
    0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89, 0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E,
    0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C, 0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83,
    0x41, 0x81, 0x80, 0x40
};

//////////////////////// 方法一 //////////////////////////////////////
// 函数功能: CRC16效验,查表法
// 输入参数: pDataIn: 数据地址
//           iLenIn: 数据长度
// 输出参数: pCRCOut: 2字节校验值
WORD CRC16_lookup(BYTE *pucFrame, int usLen)
{
    WORD iIndex;
    WORD ucCRCHi = 0xFF;
    WORD ucCRCLo = 0xFF;

    while(usLen--) {
        iIndex = ucCRCLo^*(pucFrame++);
        ucCRCLo = (BYTE)(ucCRCHi ^ aucCRCHi[iIndex]);
        ucCRCHi = aucCRCLo[iIndex];
    }

    return(WORD)(ucCRCHi << 8 | ucCRCLo);
}



//////////////////////// 方法二 //////////////////////////////////////
// 函数功能: CRC16效验
// 输入参数: pDataIn: 数据地址
//           iLenIn: 数据长度
// 输出参数: pCRCOut: 2字节校验值
static WORD CalcCRCModBus(BYTE cDataIn, WORD wCRCIn)
{
    WORD wCheck = 0;
    wCRCIn = wCRCIn ^ cDataIn;

    for(int i = 0; i < 8; i++) {
        wCheck = wCRCIn & 1;
        wCRCIn = wCRCIn >> 1;
        wCRCIn = wCRCIn & 0x7fff;

        if(wCheck == 1) {
            wCRCIn = wCRCIn ^ 0xa001;
        }

        wCRCIn = wCRCIn & 0xffff;
    }

    return wCRCIn;
}



WORD CheckCRCModBus(const BYTE *pDataIn, int iLenIn)
{
    WORD wHi = 0;
    WORD wLo = 0;
    WORD wCRC;
    wCRC = 0xFFFF;

    for(int i = 0; i < iLenIn; i++) {
        wCRC = CalcCRCModBus(*pDataIn, wCRC);
        pDataIn++;
    }

    wHi = wCRC / 256;
    wLo = wCRC % 256;
    wCRC = (wHi << 8) | wLo;
    return wCRC;
}


//校验位高低位交换，不常用
WORD CheckCRCModBus2(BYTE pDataIn[], int iLenIn)
{

    WORD wHi = 0;
    WORD wLo = 0;
    WORD wCRC;
    wCRC = 0xFFFF;

    for(int i = 0; i < iLenIn; i++) {
        wCRC = CalcCRCModBus(pDataIn[i], wCRC);
    }

    wHi = wCRC / 256;
    wLo = wCRC % 256;
    wCRC = (wLo << 8) | wHi;
    return wCRC;
}



char *my_iota(int var, int radix)
{
    static char local[33] = {0};
    char *p = &local[32];
    static unsigned char table[] = "0123456789abcdef";
    bool sign = false;
    unsigned int tmp;

    if(radix < 2 && radix > 16) {
        *p = '\0';
        return p;
    }

    if(var < 0 && radix == 10) {
        sign = true;
        var = -var;
    }

    tmp = var;
    *p-- = '\0';

    do {
        *p-- = table[tmp % radix];
        tmp /= radix;
    } while(tmp > 0);

    if(sign == true) {
        *p-- = '-';
    }

    return p + 1;
}


/****************************************************************************
 str_to_hex
*****************************************************************************/
int str_to_hex(char *string, unsigned char *cbuf, int len)
{
    BYTE high, low;
    int idx, ii = 0;

    for(idx = 0; idx < len; idx += 2) {
        high = string[idx];
        low = string[idx + 1];

        if(high >= '0' && high <= '9')
        { high = high - '0'; }
        else if(high >= 'A' && high <= 'F')
        { high = high - 'A' + 10; }
        else if(high >= 'a' && high <= 'f')
        { high = high - 'a' + 10; }
        else
        { return -1; }

        if(low >= '0' && low <= '9')
        { low = low - '0'; }
        else if(low >= 'A' && low <= 'F')
        { low = low - 'A' + 10; }
        else if(low >= 'a' && low <= 'f')
        { low = low - 'a' + 10; }
        else
        { return -1; }

        cbuf[ii++] = high << 4 | low;
    }

    return 0;
}

/****************************************************************************
hex_to_str
*****************************************************************************/
void hex_to_str(char *ptr, unsigned char *buf, int len)
{
    for(int i = 0; i < len; i++) {
        sprintf(ptr, "%02x", buf[i]);
        ptr += 2;
    }
}

void _itoa(int i, char *string)
{
    int power = 0, j = 0;
    j = i;

    for(power = 1; j > 10; j /= 10)
    { power *= 10; }

    for(; power > 0; power /= 10) {
        *string++ = '0' + i / power;
        i %= power;
    }

    *string = '\0';
}


char *itoa(int num, char *str, int radix)
{
    char index[] = "0123456789ABCDEF";
    unsigned unum;/*中间变量*/
    int i = 0, j, k;

    /*确定unum的值*/
    if(radix == 10 && num < 0) { /*十进制负数*/
        unum = (unsigned) - num;
        str[i++] = '-';
    } else {
        unum = (unsigned)num;    /*其他情况*/
    }

    /*转换*/
    do {
        str[i++] = index[unum % (unsigned)radix];
        unum /= radix;
    } while(unum);

    str[i] = '\0';

    /*逆序*/
    if(str[0] == '-')
    { k = 1; } /*十进制负数*/
    else
    { k = 0; }

    char temp;

    for(j = k; j <= (i - 1) / 2; j++) {
        temp = str[j];
        str[j] = str[i - 1 + k - j];
        str[i - 1 + k - j] = temp;
    }

    return str;
}

/*************************************************
*@Function: bcd2str_float bcd码转字符串浮点
*@Input:    bcd ：bcd码数据指针
                    ret ：接受字符串指针
                    length：bcd码总字节数 (比如967295.01,length为4)
                    id      ：小数点所在的字节数位置 (比如967295.01,id为3)
*@Return: void
*@Others: 传输的字节低位在前 (967295.11 ,bcd[0]为0x11)
*************************************************/
void bcd2str_float(uint8_t *bcd, char *ret, uint32_t length, int id)
{
    uint32_t size = length;
    uint32_t j = 0;

    for(int i = 0; i < size; i++) {
        if(i == id)
        { ret[j++] = '.'; }

        ret[j++] = (bcd[size - 1 - i] >> 4) + '0';
        ret[j++] = (bcd[size - 1 - i] & 0x0f) + '0';
    }

    ret[j++] = 0;
}


/*************************************************
*@Function: bcd2str_int bcd码转字符串整形
*@Input:    bcd ：bcd码数据指针
                    ret ：接受字符串指针
                    length：bcd码总字节数 (比如967295,length为3)
*@Return: void
*@Others: 传输的字节高字节在前 (967295 ,bcd[0]为0x95)
*************************************************/
void bcd2str_int(uint8_t *bcd, char *ret, uint32_t length)
{
    uint32_t size = length;
    uint32_t j = 0;

    for(int i = 0; i < size; i++) {
        ret[j++] = (bcd[size - 1 - i] >> 4) + '0';
        ret[j++] = (bcd[size - 1 - i] & 0x0f) + '0';
    }

    ret[j++] = 0;
}

uint8_t crc_check(uint8_t *ptr, uint32_t len)
{
    uint32_t crc = 0, crc_get;
    crc = CRC16_lookup(ptr, len - 2);
    crc_get = (ptr[len - 2] & 0xff) + (ptr[len - 1] << 8);
    return (crc == crc_get);
}


/*************************************************
*@Function: 校验和校验
*@Input:    ptr ：需校验数据指针
                    len ：校验长度
*@Return: 校验和
*@Others:
*************************************************/
uint32_t sum_check(const uint8_t *ptr, uint32_t len)
{
    uint32_t sum = 0, i;

    for(i = 0; i < len; i++) {
        sum += *ptr;
        ptr++;
    }

    return sum;
}

