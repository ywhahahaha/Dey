# Keil uVision project project.uvprojx, settings and files
target I03M (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: I03M +hex
  AfterMake: fromelf --bin --output .\Upgrade\I03M.bin .\Objects\I03M.axf
  AfterMake: .\Upgrade\generate.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,HSE_VALUE= 16000000U,OS_TYPE=0,
  c include: ..\Application;..\Bsp;..\Modules
  memory RVCT4: ROM 0x8010000 size 0x50000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1000fe00 size 0x200
  group Application
    ../Application/: typedef.h project_config.h main.c appl_comm_i03t.c appl_alarm.c appl_software.c appl_hardware.c appl_para.c appl_usbh.c appl_rs485_manage.c appl_noinit.c threads_init.c thread_comm_i03t.c thread_rs485_1.c thread_rs485_2.c thread_rs485_3.c thread_debug.c thread_4g.c thread_soc.c thread_storage.c thread_protocol_process.c thread_command.c thread_usbh.c thread_cpustat.c thread_lcd.c i03t_node.c stm32f4xx_it.c protocol_handle.c thread_creatFileTest.c thread_key.c
  group Bsp
    ../Bsp/: bsp_flash.c bsp_gpio.c bsp_rs485.c bsp_usart.c bsp_wdt.c bsp_fsmc.c bsp_rtc.c bsp_pvd.c bsp_timer.c bsp_lcd.c delay.c bsp_key.c
  group Modules
    ../Modules/: iap.c program.c logger.c malloc.c crc_check.c de_protocol.c de_modbus_protocol.c module_sn.c module_file_storage.c module_nand_storage.c module_alarm.c module_discharge.c module_hist.c module_soc.c module_log.c module_4g.c module_tas.c module_eth.c module_zlg.c module_index.c module_payload.c storage.c App_soc.c strTools.c cJSON.c sys_mem.c module_lcd_gui.c
    ../Bsp/: USBH_MSC.c
  group Docs
    ./Upgrade/: generate.bat ReadMe.txt 烧录说明.txt
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:I/O:File 1.2.0, File System:CORE 6.14.1, File System:Drive:NAND 6.14.1, File System:Drive:USB 6.14.1, USB:CORE 6.15.0, USB:Host 6.15.0, USB:Host:MSC 6.15.0, CMSIS Driver:NAND:Memory Bus 1.1.0, CMSIS Driver:USB Host:Full-speed 2.21, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:EXTI 1.7.9, Device:STM32Cube HAL:Flash 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:IWDG 1.7.9, Device:STM32Cube HAL:NAND 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:RTC 1.7.9, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:SRAM 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:STM32Cube HAL:UART 1.7.9, Device:STM32Cube HAL:USART 1.7.9, Device:Startup 2.6.3
